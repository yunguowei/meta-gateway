FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://0010-static-compilation-standard-target.patch \
	file://0020-Shared-iptables-dynamic-shared-library-path-to-fw3.patch \
        "

