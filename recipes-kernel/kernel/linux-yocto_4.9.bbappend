
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://cube-gw.scc"

